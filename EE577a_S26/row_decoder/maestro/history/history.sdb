<?xml version="1.0"?>
<setupdb version="7">history
	<active>Active Setup</active>
	<history>History
		<historyentry assemblerOrExplorer="explorer" roOrView="view" runningOrFinished="finished">ExplorerRun.0
			<timestamp>Apr 2 14:43:49 2026</timestamp>
			<uuid>{5a6c89c1-32e1-4f30-91a7-d0ea7fc1bec7}</uuid>
			<locked>0</locked>
			<mode>Single Run, Sweeps and Corners</mode>
			<resultsname>/home/tlin9034@vlab.usc.edu/work_gpdk045/EE577a_S26/row_decoder/maestro/results/maestro/$AXL_HISTORY_NAME.rdb</resultsname>
			<simresults>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.rdb</simresults>
			<runlog>/home/tlin9034@vlab.usc.edu/work_gpdk045/EE577a_S26/row_decoder/maestro/results/maestro/$AXL_HISTORY_NAME.log</runlog>
			<runlogfile>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.log</runlogfile>
			<psfdir>/home/tlin9034@vlab.usc.edu/simulation/results/maestro/ExplorerRun.0</psfdir>
			<simdir>/home/tlin9034@vlab.usc.edu/simulation/results/maestro/ExplorerRun.0</simdir>
		</historyentry>
	</history>
</setupdb>
